options:
  parameters:
    author: mike
    generate_options: qt_gui
    id: fm_bd2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '3000'
    gain: '1.0'
    samp_rate: '16000'
    width: '100'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: var_volume
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.05'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '3200'
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '2'
    quad_rate: '64000'
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '16000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: var_volume
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"RAW"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Post-FM"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '3200'
    interp: '16000'
    taps: ''
    type: fff
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://bd2.elasticninja.com:10001
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_nbfm_rx_0, '0', rational_resampler_xxx_0, '0']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_waterfall_sink_x_1, '0']
- [blocks_throttle_0, '0', analog_nbfm_rx_0, '0']
- [blocks_throttle_0, '0', analog_wfm_rcv_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [zeromq_sub_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
